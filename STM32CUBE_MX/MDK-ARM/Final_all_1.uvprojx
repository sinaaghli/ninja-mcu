# Keil uVision project Final_all_1.uvprojx, settings and files
target Final_all_1 Configuration (ARM-ADS)
  device: STM32F207VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F2xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_cortex.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash.c stm32f2xx_hal_tim.c stm32f2xx_hal_adc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_dma.c stm32f2xx_hal_pwr.c stm32f2xx_hal_uart.c
  group Application/User
    ../Src/: i2c.c dma.c gpio.c tim.c main.c usart.c stm32f2xx_it.c adc.c stm32f2xx_hal_msp.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f207xx.s
software components: CMSIS:CORE 4.1.0
